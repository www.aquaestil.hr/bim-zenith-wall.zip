Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-05T14:56:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 05 14:56:48 2021 * Host: pr500ssd * Database: C:\Users\PREDRA~1.RAK\AppData\Local\Temp\{71A8F8E8-5785-4C2B-BA4B-7CBA9BFEBD9E}\ifc * Database version: 5507 * Database creation date: Fri Mar 05 14:56:48 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 05 14:56:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 05 14:56:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: STIJENA 200, Zenit Wall:STIJENA 200:358733
In: Level 1
Type - Material: Srebrni profil, Prozirno staklo
Type - Constraints - A: 1990 mm
Type - Dimensions - A (ugradbena mjera s profilima): 1990 mm; Visina: 2000 mm
Type - Identity Data - Boja profila: crna, srebrna; Izradio: Intelika d.o.o; Manufacturer: Aquaestil; Model: Zenith Wall; Type Name: STIJENA 200; Web adresa: https://www.aquaestil.hr/hr/proizvodi/paravani/21-zenith-wall.html
Type - Materials and Finishes - Material: Srebrni profil; Material glass: Prozirno staklo
Type - Other - Category: Generic Models; Family Name: Zenit Wall
Pset_BuildingElementProxyCommon - Reference: Zenit Wall:STIJENA 200
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil
Constraints - Dubina: 1040 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 4.2899 m2; Dubina paravana: 1040 mm; Volume: 0.0350922 m3
Other - Family: Zenit Wall: STIJENA 200; Family and Type: Zenit Wall: STIJENA 200; Type: Zenit Wall: STIJENA 200; Type Id: Zenit Wall: STIJENA 200
Phasing - Phase Created: New Construction
